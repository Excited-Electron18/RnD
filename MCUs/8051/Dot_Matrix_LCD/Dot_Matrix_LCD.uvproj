# Keil uVision project Dot_Matrix_LCD.uvproj, settings and files
target 89C51 (MCS-51)
  device: AT80C51RD2 Microchip
  cpu: IRAM(0x00 - 0xFF) XRAM(0x00 - 0x3FF) CLOCK(40000000) MODP2
  output: Dot_Matrix_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Lib
    ./: STARTUP.A51
  group Source
    ./Source/: main.c
  group Header
    ./Header/: Dot_Matrix_LCD_4bit_Mode.h
