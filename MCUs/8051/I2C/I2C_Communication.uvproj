# Keil uVision project I2C_Communication.uvproj, settings and files
target 89C51 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: I2C_Communication
  c flags: Optimize=8 SizeSpeed=1
  group Lib
    ./: STARTUP.A51
  group Source
    ./Source/: main.c
  group Header
    ./Header/: I2C.c I2C.h
