# Keil uVision project 8051_Sample_Test.uvproj, settings and files
target 80C51 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_Sample_Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Lib
    ./: STARTUP.A51
  group Source
    ./Source/: main.c
  group Library
    ./Library/: Global.h Dot_Matrix_LCD_4bit_Mode.c Dot_Matrix_LCD_4bit_Mode.h Ext_Interrupt.c Ext_Interrupt.h I2C.c I2C.h UART.c UART.h Timer.h Timer.c Power_Mode.h Power_Mode.c SPI.c SPI.h
  group Sample_Test
    ./Sample_Test/: Dot_Matrix_LCD.c External_Interrupt.c I2C_Interface.c UART_Interface.c Power_Modes.c Timer_Test.c SPI_Interface.c
